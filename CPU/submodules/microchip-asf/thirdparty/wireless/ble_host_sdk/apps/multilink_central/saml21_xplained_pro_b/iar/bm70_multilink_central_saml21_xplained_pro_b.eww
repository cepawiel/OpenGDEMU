<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\bm70_multilink_central_saml21_xplained_pro_b_flash.ewp</path>
	</project>
</workspace>
