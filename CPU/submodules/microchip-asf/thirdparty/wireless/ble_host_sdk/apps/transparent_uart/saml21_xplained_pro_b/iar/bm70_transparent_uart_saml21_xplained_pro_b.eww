<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\bm70_transparent_uart_saml21_xplained_pro_b_flash.ewp</path>
	</project>
</workspace>
