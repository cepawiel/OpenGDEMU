<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\bm70_ibeacon_saml21_xplained_pro_b_flash.ewp</path>
	</project>
</workspace>
