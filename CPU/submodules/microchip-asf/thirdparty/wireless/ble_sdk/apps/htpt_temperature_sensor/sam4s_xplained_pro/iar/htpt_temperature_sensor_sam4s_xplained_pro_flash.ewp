# IAR project htpt_temperature_sensor_sam4s_xplained_pro_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4SD32C Atmel SAM4SD32C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: HOST_UART_BAUDRATE_CONFIG_VALUE=921600; DEVICE_INFORMATION_SERVICE; NEW_EVT_HANDLER; UART_FLOWCONTROL_4WIRE_MODE=true; ATT_DB_MEMORY; BLE_DEVICE_ROLE=BLE_ROLE_PERIPHERAL; BOARD=SAM4S_XPLAINED_PRO; BLE_MODULE=BTLC1000_ZR; BOARD_AT30TSE_DEVICE_ADDR=0x0; HTPT_SERVICE; __SAM4SD32C__; UART_FLOWCONTROL_6WIRE_MODE=false; NENABLE_PTS=false; ENABLE_POWER_SAVE; ARM_MATH_CM4=true; HOST_SLEEP_ENABLE=true; SLEEP_WALKING_ENABLED=false
  ICCARM.CCIncludePath2: ../../../../../../../sam/boards/sam4s_xplained_pro; ../../../../../../../sam/utils/header_files; ../../../../../../../sam/utils/preprocessor; ../../../../ble_services/ble_mgr; ../../../../../../../sam/drivers/pio; ../../../../../../../sam/utils/cmsis/sam4s/include; ../../../../services/timer; ../../../../services/console; ../../../../../../../common/services/gpio; ../../../../../../../common/components/memory/eeprom/at30tse75x; ../../../../../../../common/services/serial; ../../../../services/serial/uart; ../..; ../../../config/sam4s; ../../../../../../../sam/drivers/pdc; ../../../../../../../common/utils; ../../../../../../../sam/drivers/wdt; ../../../../ble_services/device_infomation; ../../../../../../../common/services/clock; ../../../../../../../sam/boards; ../../../../../../../common/utils/stdio/stdio_serial; ../../../../inc; ../../../../../../../common/services/sleepmgr; ../../../../../../../common/services/delay; ../../../../../../../common/services/twi; ../../../../../../../sam/utils/cmsis/sam4s/source/templates; ../../../../../../../sam/drivers/pdc/pdc_uart_example; ../../../../../../../sam/drivers/uart; ../../../../../../../sam/utils; ../../../../utils; ../../../../../../../sam/drivers/tc; ../../../../../../../sam/drivers/usart; ../../../../../../../common/services/serial/sam_uart; ../../../../../../../common/boards; ../../../../../../../common/services/ioport; ../../../../../../../sam/drivers/pmc; ../../../../services/serial_fifo; ../../../../../../../sam/drivers/twi; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: htpt_temperature_sensor_sam4s_xplained_pro_flash.bin
  ILINK.IlinkOutputFile: htpt_temperature_sensor_sam4s_xplained_pro_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../sam/utils/linker_scripts/sam4s/sam4sd32/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/wireless/ble_sdk/lib/cm4f/iar
    ../../../../lib/cm4f/iar/: libble_sdk.a
  group thirdparty/wireless/ble_sdk/apps/htpt_temperature_sensor
    ../../: htpt_app.c htpt_app.h
  group thirdparty/wireless/ble_sdk/apps/htpt_temperature_sensor/sam4s_xplained_pro/iar
    ./: asf.h
  group thirdparty/wireless/ble_sdk/apps/config/sam4s
    ../../../config/sam4s/: conf_uart_serial.h conf_clock.h conf_timer.h conf_sleepmgr.h conf_serialdrv.h conf_extint.h conf_board.h
  group thirdparty/wireless/ble_sdk/services/serial_fifo
    ../../../../services/serial_fifo/: serial_fifo.c serial_fifo.h
  group thirdparty/wireless/ble_sdk/services/serial/uart
    ../../../../services/serial/uart/: serial_drv.h
  group thirdparty/wireless/ble_sdk/services/serial/uart/sam
    ../../../../services/serial/uart/sam/: serial_drv.c
  group thirdparty/wireless/ble_sdk/services/timer
    ../../../../services/timer/: timer_hw.h
  group thirdparty/wireless/ble_sdk/services/timer/sam
    ../../../../services/timer/sam/: timer_hw.c
  group thirdparty/wireless/ble_sdk/services/console
    ../../../../services/console/: console_serial.h
  group thirdparty/wireless/ble_sdk/services/console/sam
    ../../../../services/console/sam/: console_serial.c
  group thirdparty/wireless/ble_sdk/src
    ../../../../src/: platform.c
  group thirdparty/wireless/ble_sdk/ble_services/device_infomation
    ../../../../ble_services/device_infomation/: device_info.c device_info.h
  group thirdparty/wireless/ble_sdk/ble_services/ble_mgr
    ../../../../ble_services/ble_mgr/: ble_manager.c ble_manager.h
  group thirdparty/wireless/ble_sdk/inc
    ../../../../inc/: platform.h at_ble_api.h at_ble_errno.h at_ble_trace.h profiles.h
  group thirdparty/wireless/ble_sdk/utils
    ../../../../utils/: ble_utils.h
  group sam/drivers/twi
    ../../../../../../../sam/drivers/twi/: twi.c twi.h
  group sam/drivers/pio
    ../../../../../../../sam/drivers/pio/: pio_handler.c pio.c pio_handler.h pio.h
  group sam/drivers/pmc
    ../../../../../../../sam/drivers/pmc/: pmc.c sleep.c sleep.h pmc.h
  group sam/drivers/tc
    ../../../../../../../sam/drivers/tc/: tc.c tc.h
  group sam/drivers/usart
    ../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/pdc
    ../../../../../../../sam/drivers/pdc/: pdc.c pdc.h
  group sam/drivers/pdc/pdc_uart_example
    ../../../../../../../sam/drivers/pdc/pdc_uart_example/: pdc_uart_example.h
  group sam/drivers/wdt
    ../../../../../../../sam/drivers/wdt/: wdt.c wdt.h
  group sam/drivers/uart
    ../../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/utils
    ../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4s/source/templates
    ../../../../../../../sam/utils/cmsis/sam4s/source/templates/: system_sam4s.c
  group sam/utils/cmsis/sam4s/source/templates/iar
    ../../../../../../../sam/utils/cmsis/sam4s/source/templates/iar/: startup_sam4s.c
  group sam/utils/cmsis/sam4s/include
    ../../../../../../../sam/utils/cmsis/sam4s/include/: sam4s16c.h sam4sd32c.h sam4s2b.h sam4s4b.h system_sam4s.h sam4sd32b.h sam4sd16b.h sam4s16b.h sam4sa16c.h sam4s8b.h sam4sd16c.h sam4s.h sam4s8c.h sam4sa16b.h sam4s4c.h sam4s2a.h sam4s4a.h sam4s2c.h
  group sam/utils/cmsis/sam4s/include/instance
    ../../../../../../../sam/utils/cmsis/sam4s/include/instance/: instance_adc.h instance_piob.h instance_udp.h instance_matrix.h instance_ssc.h instance_chipid.h instance_acc.h instance_rstc.h instance_hsmci.h instance_twi0.h instance_efc1.h instance_rtt.h instance_tc0.h instance_usart1.h instance_supc.h instance_pmc.h instance_uart0.h instance_uart1.h instance_gpbr.h instance_smc.h instance_efc0.h instance_pioa.h instance_rtc.h instance_pioc.h instance_tc1.h instance_cmcc.h instance_dacc.h instance_pwm.h instance_wdt.h instance_spi.h instance_crccu.h instance_twi1.h instance_usart0.h
  group sam/utils/cmsis/sam4s/include/component
    ../../../../../../../sam/utils/cmsis/sam4s/include/component/: component_twi.h component_acc.h component_pio.h component_spi.h component_hsmci.h component_rstc.h component_usart.h component_chipid.h component_adc.h component_smc.h component_wdt.h component_udp.h component_pwm.h component_dacc.h component_cmcc.h component_matrix.h component_efc.h component_gpbr.h component_ssc.h component_pmc.h component_supc.h component_rtt.h component_crccu.h component_rtc.h component_uart.h component_pdc.h component_tc.h
  group sam/utils/cmsis/sam4s/include/pio
    ../../../../../../../sam/utils/cmsis/sam4s/include/pio/: pio_sam4s16b.h pio_sam4s4b.h pio_sam4sd16c.h pio_sam4s2c.h pio_sam4s8b.h pio_sam4s2a.h pio_sam4sd32b.h pio_sam4s2b.h pio_sam4sa16c.h pio_sam4sd32c.h pio_sam4sa16b.h pio_sam4sd16b.h pio_sam4s4c.h pio_sam4s4a.h pio_sam4s8c.h pio_sam4s16c.h
  group sam/utils/header_files
    ../../../../../../../sam/utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../../../../sam/utils/preprocessor/: stringz.h mrepeat.h tpaste.h preprocessor.h
  group sam/boards/sam4s_xplained_pro
    ../../../../../../../sam/boards/sam4s_xplained_pro/: init.c led.h sam4s_xplained_pro.h
  group common/utils
    ../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/stdio
    ../../../../../../../common/utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/clock
    ../../../../../../../common/services/clock/: sysclk.h osc.h pll.h genclk.h
  group common/services/clock/sam4s
    ../../../../../../../common/services/clock/sam4s/: sysclk.c pll.h osc.h sysclk.h genclk.h
  group common/services/sleepmgr
    ../../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../../common/services/sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/serial
    ../../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/delay
    ../../../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/gpio
    ../../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/services/twi
    ../../../../../../../common/services/twi/: twi_master.h twi_slave.h
  group common/services/twi/sam_twi
    ../../../../../../../common/services/twi/sam_twi/: twi_master.h twi_slave.h
  group common/services/ioport
    ../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/components/memory/eeprom/at30tse75x
    ../../../../../../../common/components/memory/eeprom/at30tse75x/: at30tse75x.c at30tse75x.h
  group common/boards
    ../../../../../../../common/boards/: board.h
