# IAR project htpt_temperature_sensor_samg55_xplained_pro_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMG55J19 Atmel SAMG55J19
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAMG55_XPLAINED_PRO; HOST_UART_BAUDRATE_CONFIG_VALUE=921600; DEVICE_INFORMATION_SERVICE; NEW_EVT_HANDLER; UART_FLOWCONTROL_4WIRE_MODE=true; __SAMG55J19__; ATT_DB_MEMORY; BLE_DEVICE_ROLE=BLE_ROLE_PERIPHERAL; BLE_MODULE=BTLC1000_ZR; BOARD_AT30TSE_DEVICE_ADDR=0x0; HTPT_SERVICE; UART_FLOWCONTROL_6WIRE_MODE=false; NENABLE_PTS=false; ENABLE_POWER_SAVE; ARM_MATH_CM4=true; HOST_SLEEP_ENABLE=true; SLEEP_WALKING_ENABLED=false
  ICCARM.CCIncludePath2: ../../../../../../../sam/utils/header_files; ../../../../../../../sam/utils/preprocessor; ../../../../ble_services/ble_mgr; ../../../../../../../sam/drivers/pmc; ../../../../../../../sam/drivers/flexcom; ../../../../services/timer; ../../../../../../../sam/drivers/efc; ../../../../../../../sam/utils/fpu; ../../../../../../../common/components/memory/eeprom/at30tse75x; ../../../../../../../common/services/serial; ../../../../services/serial/uart; ../..; ../../../../../../../sam/boards/samg55_xplained_pro; ../../../../../../../sam/drivers/supc; ../../../../../../../sam/drivers/pdc; ../../../../../../../common/utils; ../../../../../../../sam/utils/cmsis/samg/samg55/source/templates; ../../../../ble_services/device_infomation; ../../../../../../../common/services/clock; ../../../../../../../sam/boards; ../../../../../../../common/utils/stdio/stdio_serial; ../../../../inc; ../../../../../../../common/services/sleepmgr; ../../../../../../../common/services/delay; ../../../../../../../common/services/twi; ../../../../../../../sam/drivers/pdc/pdc_uart_example; ../../../../../../../sam/utils; ../../../../utils; ../../../../../../../sam/drivers/tc; ../../../../../../../sam/drivers/usart; ../../../../../../../common/services/serial/sam_uart; ../../../../../../../common/boards; ../../../../services/console; ../../../../../../../common/services/ioport; ../../../../../../../sam/drivers/pio; ../../../../services/serial_fifo; ../../../config/samg55; ../../../../../../../sam/utils/cmsis/samg/samg55/include; ../../../../../../../sam/drivers/twi; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: htpt_temperature_sensor_samg55_xplained_pro_flash.bin
  ILINK.IlinkOutputFile: htpt_temperature_sensor_samg55_xplained_pro_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../sam/utils/linker_scripts/samg/samg55j19/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/wireless/ble_sdk/lib/cm4f/iar
    ../../../../lib/cm4f/iar/: libble_sdk.a
  group thirdparty/wireless/ble_sdk/apps/htpt_temperature_sensor
    ../../: htpt_app.c htpt_app.h
  group thirdparty/wireless/ble_sdk/apps/htpt_temperature_sensor/samg55_xplained_pro/iar
    ./: asf.h
  group thirdparty/wireless/ble_sdk/apps/config/samg55
    ../../../config/samg55/: conf_extint.h conf_sleepmgr.h conf_board.h conf_uart_serial.h conf_timer.h conf_clock.h conf_serialdrv.h
  group thirdparty/wireless/ble_sdk/services/serial_fifo
    ../../../../services/serial_fifo/: serial_fifo.c serial_fifo.h
  group thirdparty/wireless/ble_sdk/services/serial/uart
    ../../../../services/serial/uart/: serial_drv.h
  group thirdparty/wireless/ble_sdk/services/serial/uart/sam
    ../../../../services/serial/uart/sam/: serial_drv.c
  group thirdparty/wireless/ble_sdk/services/timer
    ../../../../services/timer/: timer_hw.h
  group thirdparty/wireless/ble_sdk/services/timer/sam
    ../../../../services/timer/sam/: timer_hw.c
  group thirdparty/wireless/ble_sdk/services/console
    ../../../../services/console/: console_serial.h
  group thirdparty/wireless/ble_sdk/services/console/sam
    ../../../../services/console/sam/: console_serial.c
  group thirdparty/wireless/ble_sdk/src
    ../../../../src/: platform.c
  group thirdparty/wireless/ble_sdk/ble_services/device_infomation
    ../../../../ble_services/device_infomation/: device_info.c device_info.h
  group thirdparty/wireless/ble_sdk/ble_services/ble_mgr
    ../../../../ble_services/ble_mgr/: ble_manager.c ble_manager.h
  group thirdparty/wireless/ble_sdk/inc
    ../../../../inc/: platform.h at_ble_errno.h at_ble_api.h at_ble_trace.h profiles.h
  group thirdparty/wireless/ble_sdk/utils
    ../../../../utils/: ble_utils.h
  group sam/boards/samg55_xplained_pro
    ../../../../../../../sam/boards/samg55_xplained_pro/: board_init.c led.h samg55_xplained_pro.h
  group sam/drivers/twi
    ../../../../../../../sam/drivers/twi/: twi.c twi.h
  group sam/drivers/pio
    ../../../../../../../sam/drivers/pio/: pio_handler.c pio.c pio_handler.h pio.h
  group sam/drivers/pmc
    ../../../../../../../sam/drivers/pmc/: pmc.c sleep.c sleep.h pmc.h
  group sam/drivers/tc
    ../../../../../../../sam/drivers/tc/: tc.c tc.h
  group sam/drivers/flexcom
    ../../../../../../../sam/drivers/flexcom/: flexcom.c flexcom.h
  group sam/drivers/usart
    ../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/pdc
    ../../../../../../../sam/drivers/pdc/: pdc.c pdc.h
  group sam/drivers/pdc/pdc_uart_example
    ../../../../../../../sam/drivers/pdc/pdc_uart_example/: pdc_uart_example.h
  group sam/drivers/supc
    ../../../../../../../sam/drivers/supc/: supc.c supc.h
  group sam/drivers/efc
    ../../../../../../../sam/drivers/efc/: efc.c efc.h
  group sam/utils
    ../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/samg/samg55/source/templates
    ../../../../../../../sam/utils/cmsis/samg/samg55/source/templates/: system_samg55.c
  group sam/utils/cmsis/samg/samg55/source/templates/iar
    ../../../../../../../sam/utils/cmsis/samg/samg55/source/templates/iar/: startup_samg55.c
  group sam/utils/cmsis/samg/samg55/include
    ../../../../../../../sam/utils/cmsis/samg/samg55/include/: samg55.h system_samg55.h samg55n19.h samg55g19.h samg55g18.h samg55j18.h samg55j19.h
  group sam/utils/cmsis/samg/samg55/include/instance
    ../../../../../../../sam/utils/cmsis/samg/samg55/include/instance/: usart5.h twi0.h usart7.h matrix.h twi2.h i2sc1.h supc.h mem2mem.h flexcom4.h flexcom6.h twi6.h udp.h pioa.h gpbr.h flexcom0.h usart4.h spi2.h twi1.h pmc.h flexcom2.h rtt.h twi3.h twi5.h tc1.h flexcom5.h spi1.h spi6.h twi7.h i2sc0.h crccu.h flexcom7.h usart2.h spi4.h flexcom1.h spi3.h rtc.h usart3.h efc.h flexcom3.h pdmic1.h adc.h tc0.h cmcc.h spi7.h usart6.h spi5.h usart1.h usart0.h rstc.h piob.h wdt.h pdmic0.h twi4.h chipid.h uhp.h spi0.h
  group sam/utils/cmsis/samg/samg55/include/component
    ../../../../../../../sam/utils/cmsis/samg/samg55/include/component/: matrix.h efc.h tc.h chipid.h flexcom.h crccu.h pio.h adc.h i2sc.h rstc.h supc.h twi.h mem2mem.h uhp.h gpbr.h cmcc.h rtt.h wdt.h pmc.h spi.h usart.h pdc.h udp.h pdmic.h rtc.h
  group sam/utils/cmsis/samg/samg55/include/pio
    ../../../../../../../sam/utils/cmsis/samg/samg55/include/pio/: samg55j18.h samg55g19.h samg55j19.h samg55g18.h samg55n19.h
  group sam/utils/fpu
    ../../../../../../../sam/utils/fpu/: fpu.h
  group sam/utils/header_files
    ../../../../../../../sam/utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../../../../sam/utils/preprocessor/: mrepeat.h tpaste.h stringz.h preprocessor.h
  group common/services/clock
    ../../../../../../../common/services/clock/: sysclk.h osc.h genclk.h pll.h
  group common/services/clock/samg
    ../../../../../../../common/services/clock/samg/: sysclk.c pll.h osc.h sysclk.h genclk.h
  group common/services/sleepmgr
    ../../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../../common/services/sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/serial
    ../../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/delay
    ../../../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/twi
    ../../../../../../../common/services/twi/: twi_slave.h twi_master.h
  group common/services/twi/sam_twi
    ../../../../../../../common/services/twi/sam_twi/: twi_master.h twi_slave.h
  group common/services/ioport
    ../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/utils
    ../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/stdio
    ../../../../../../../common/utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/components/memory/eeprom/at30tse75x
    ../../../../../../../common/components/memory/eeprom/at30tse75x/: at30tse75x.c at30tse75x.h
  group common/boards
    ../../../../../../../common/boards/: board.h
