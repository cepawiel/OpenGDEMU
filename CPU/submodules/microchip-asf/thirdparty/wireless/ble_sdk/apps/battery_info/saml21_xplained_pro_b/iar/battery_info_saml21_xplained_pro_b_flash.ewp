# IAR project battery_info_saml21_xplained_pro_b_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAML21J18B Atmel ATSAML21J18B
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: SYSTICK_MODE; HOST_UART_BAUDRATE_CONFIG_VALUE=921600; NEW_EVT_HANDLER; BOARD=SAML21_XPLAINED_PRO; NENABLE_PTS; TC_ASYNC=true; ATT_DB_MEMORY; EXTINT_CALLBACK_MODE=true; BLE_DEVICE_ROLE=BLE_ROLE_PERIPHERAL; BLE_MODULE=BTLC1000_ZR; UART_FLOWCONTROL_6WIRE_MODE=true; ARM_MATH_CM0PLUS=true; USART_CALLBACK_MODE=true; __SAML21J18B__; UART_FLOWCONTROL_4WIRE_MODE=false; BATTERY_SERVICE; ENABLE_POWER_SAVE; PDS_SERVICE; HOST_SLEEP_ENABLE=true; SLEEP_WALKING_ENABLED=false
  ICCARM.CCIncludePath2: ../../../../../../../sam0/drivers/port; ../../../../../../../sam0/drivers/system/reset; ../../../../ble_services/ble_mgr; ../../../../../../../sam0/utils/preprocessor; ../../../../../../../sam0/boards/saml21_xplained_pro_b; ../../../../../../../common2/services/delay; ../../../../ble_services/battery; ../../../../../../../sam0/utils; ../../../../services/timer; ../../../../../../../sam0/drivers/nvm; ../../../../../../../sam0/drivers/sercom; ../../../../../../../sam0/drivers/system/power; ../../../../../../../sam0/boards; ../../../../../../../sam0/drivers/sercom/usart; ../../../../../../../common/services/serial; ../../../config/saml21; ../../../../../../../sam0/utils/cmsis/saml21/include_b; ../../../../services/serial/uart; ../../../../../../../sam0/drivers/tc/tc_sam_l_c; ../../../../../../../common/utils; ../../../../../../../sam0/drivers/system/interrupt; ../../../../../../../sam0/drivers/system/power/power_sam_l; ../../../../../../../sam0/drivers/tc; ../../../../services/pds; ../../../../inc; ../../../../../../../sam0/utils/cmsis/saml21/source; ../../../../../../../sam0/drivers/system/interrupt/system_interrupt_saml21; ../../../../../../../sam0/drivers/extint/extint_sam_l_c; ../../../../../../../common2/services/delay/sam0; ../..; ../../../../utils; ../../../../../../../sam0/drivers/system/clock/clock_saml21; ../../../../../../../common/boards; ../../../../../../../sam0/drivers/system/reset/reset_sam_l; ../../../../../../../sam0/drivers/system/pinmux; ../../../../services/console; ../../../../../../../sam0/drivers/system; ../../../../../../../sam0/drivers/extint; ../../../../services/serial_fifo; ../../../../../../../sam0/utils/header_files; ../../../../../../../sam0/utils/stdio/stdio_serial; ../../../../../../../sam0/drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: battery_info_saml21_xplained_pro_b_flash.bin
  ILINK.IlinkOutputFile: battery_info_saml21_xplained_pro_b_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../sam0/utils/linker_scripts/saml21/iar/saml21j18b_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/wireless/ble_sdk/lib/cm0p/iar
    ../../../../lib/cm0p/iar/: libble_sdk.a
  group thirdparty/wireless/ble_sdk/services/serial_fifo
    ../../../../services/serial_fifo/: serial_fifo.c serial_fifo.h
  group thirdparty/wireless/ble_sdk/services/timer
    ../../../../services/timer/: timer_hw.h
  group thirdparty/wireless/ble_sdk/services/timer/sam0
    ../../../../services/timer/sam0/: timer_hw.c
  group thirdparty/wireless/ble_sdk/services/serial/uart
    ../../../../services/serial/uart/: serial_drv.h
  group thirdparty/wireless/ble_sdk/services/serial/uart/sam0
    ../../../../services/serial/uart/sam0/: serial_drv.c
  group thirdparty/wireless/ble_sdk/services/console
    ../../../../services/console/: console_serial.h
  group thirdparty/wireless/ble_sdk/services/console/sam0
    ../../../../services/console/sam0/: console_serial.c
  group thirdparty/wireless/ble_sdk/services/pds
    ../../../../services/pds/: pds.c pds.h pds_nvm.h
  group thirdparty/wireless/ble_sdk/services/pds/sam0
    ../../../../services/pds/sam0/: pds_nvm.c
  group thirdparty/wireless/ble_sdk/src
    ../../../../src/: platform.c
  group thirdparty/wireless/ble_sdk/apps/battery_info
    ../../: battery_info.c battery_info.h
  group thirdparty/wireless/ble_sdk/apps/battery_info/saml21_xplained_pro_b/iar
    ./: asf.h
  group thirdparty/wireless/ble_sdk/apps/config/saml21
    ../../../config/saml21/: conf_extint.h conf_timer.h conf_board.h conf_console.h conf_serialdrv.h conf_clocks.h conf_nvm.h
  group thirdparty/wireless/ble_sdk/ble_services/ble_mgr
    ../../../../ble_services/ble_mgr/: ble_manager.c ble_manager.h
  group thirdparty/wireless/ble_sdk/ble_services/battery
    ../../../../ble_services/battery/: battery.c battery.h
  group thirdparty/wireless/ble_sdk/inc
    ../../../../inc/: platform.h at_ble_errno.h at_ble_api.h at_ble_trace.h profiles.h
  group thirdparty/wireless/ble_sdk/utils
    ../../../../utils/: ble_utils.h
  group sam0/utils
    ../../../../../../../sam0/utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/saml21/source
    ../../../../../../../sam0/utils/cmsis/saml21/source/: system_saml21.c system_saml21.h
  group sam0/utils/cmsis/saml21/source/iar
    ../../../../../../../sam0/utils/cmsis/saml21/source/iar/: startup_saml21.c
  group sam0/utils/cmsis/saml21/include_b
    ../../../../../../../sam0/utils/cmsis/saml21/include_b/: saml21e15b.h saml21j17b.h saml21j18b.h saml21g18b.h saml21e18b.h saml21g16b.h saml21j16b.h saml21.h saml21g17b.h saml21e16b.h saml21e17b.h
  group sam0/utils/cmsis/saml21/include_b/instance
    ../../../../../../../sam0/utils/cmsis/saml21/include_b/instance/: tc0.h gclk.h tcc1.h oscctrl.h sercom0.h dmac.h sercom3.h eic.h mtb.h osc32kctrl.h pac.h tc1.h usb.h sercom4.h tc3.h rstc.h trng.h sercom5.h sercom2.h rtc.h ac.h port.h pm.h tc2.h ccl.h tc4.h dac.h wdt.h tal.h dsu.h supc.h tcc2.h evsys.h opamp.h sercom1.h tcc0.h adc.h nvmctrl.h aes.h mclk.h
  group sam0/utils/cmsis/saml21/include_b/pio
    ../../../../../../../sam0/utils/cmsis/saml21/include_b/pio/: saml21g18b.h saml21e16b.h saml21j17b.h saml21e15b.h saml21e17b.h saml21g16b.h saml21e18b.h saml21j16b.h saml21g17b.h saml21j18b.h
  group sam0/utils/cmsis/saml21/include_b/component
    ../../../../../../../sam0/utils/cmsis/saml21/include_b/component/: gclk.h pm.h trng.h sercom.h oscctrl.h port.h wdt.h mtb.h opamp.h pac.h dsu.h dac.h mclk.h adc.h usb.h osc32kctrl.h tal.h dmac.h supc.h evsys.h ac.h rtc.h rstc.h aes.h ccl.h tc.h tcc.h eic.h nvmctrl.h
  group sam0/utils/stdio
    ../../../../../../../sam0/utils/stdio/: read.c write.c
  group sam0/utils/stdio/stdio_serial
    ../../../../../../../sam0/utils/stdio/stdio_serial/: stdio_serial.h
  group sam0/utils/preprocessor
    ../../../../../../../sam0/utils/preprocessor/: mrepeat.h mrecursion.h tpaste.h preprocessor.h stringz.h
  group sam0/utils/header_files
    ../../../../../../../sam0/utils/header_files/: io.h
  group sam0/drivers/tc
    ../../../../../../../sam0/drivers/tc/: tc_interrupt.c tc.h tc_interrupt.h
  group sam0/drivers/tc/tc_sam_l_c
    ../../../../../../../sam0/drivers/tc/tc_sam_l_c/: tc.c
  group sam0/drivers/port
    ../../../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/system
    ../../../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../../../../sam0/drivers/system/clock/: clock.h gclk.h
  group sam0/drivers/system/clock/clock_saml21
    ../../../../../../../sam0/drivers/system/clock/clock_saml21/: clock.c gclk.c clock_feature.h clock_config_check.h
  group sam0/drivers/system/interrupt
    ../../../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_saml21
    ../../../../../../../sam0/drivers/system/interrupt/system_interrupt_saml21/: system_interrupt_features.h
  group sam0/drivers/system/pinmux
    ../../../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/power/power_sam_l
    ../../../../../../../sam0/drivers/system/power/power_sam_l/: power.h
  group sam0/drivers/system/reset/reset_sam_l
    ../../../../../../../sam0/drivers/system/reset/reset_sam_l/: reset.h
  group sam0/drivers/extint
    ../../../../../../../sam0/drivers/extint/: extint_callback.c extint_callback.h extint.h
  group sam0/drivers/extint/extint_sam_l_c
    ../../../../../../../sam0/drivers/extint/extint_sam_l_c/: extint.c
  group sam0/drivers/sercom
    ../../../../../../../sam0/drivers/sercom/: sercom.c sercom_interrupt.c sercom.h sercom_pinout.h sercom_interrupt.h
  group sam0/drivers/sercom/usart
    ../../../../../../../sam0/drivers/sercom/usart/: usart.c usart_interrupt.c usart_interrupt.h usart.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../../../../../../sam0/drivers/sercom/usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../../../../sam0/drivers/sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/sercom/usart/quick_start_lin
    ../../../../../../../sam0/drivers/sercom/usart/quick_start_lin/: qs_lin.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../../../../sam0/drivers/sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/nvm
    ../../../../../../../sam0/drivers/nvm/: nvm.c nvm.h
  group sam0/drivers/nvm/quick_start_basic
    ../../../../../../../sam0/drivers/nvm/quick_start_basic/: qs_nvm_basic.h
  group sam0/boards/saml21_xplained_pro_b
    ../../../../../../../sam0/boards/saml21_xplained_pro_b/: board_init.c saml21_xplained_pro.h
  group common2/services/delay
    ../../../../../../../common2/services/delay/: delay.h
  group common2/services/delay/sam0
    ../../../../../../../common2/services/delay/sam0/: systick_counter.c systick_counter.h
  group common/utils
    ../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/serial
    ../../../../../../../common/services/serial/: serial.h
  group common/services/serial/sam0_usart
    ../../../../../../../common/services/serial/sam0_usart/: usart_serial.h
  group common/boards
    ../../../../../../../common/boards/: board.h
