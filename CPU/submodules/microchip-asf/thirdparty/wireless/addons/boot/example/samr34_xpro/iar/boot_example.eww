<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\boot_example_flash.ewp</path>
	</project>
</workspace>
