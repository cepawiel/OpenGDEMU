# IAR project boot_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMR34J18B Atmel ATSAMR34J18B
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAMR34J18B__; ARM_MATH_CM0PLUS=true; EXTINT_CALLBACK_MODE=true; USART_CALLBACK_MODE=true; BOARD=SAMR34_XPLAINED_PRO
  ICCARM.CCIncludePath2: ../../../../../../../sam0/drivers/system/power; ../../../../../../../sam0/drivers/system/reset; ../../../../../../../sam0/utils/preprocessor; ../../../../../../../sam0/utils; ../../../bootloader/inc; ../../../../../../../sam0/drivers/nvm; ../../../../../../../sam0/drivers/sercom; ../../../../../../../sam0/drivers/port; ../../../../../../../sam0/boards; ../../../../../../../sam0/drivers/sercom/usart; ../../../../../../../sam0/utils/cmsis/samr34/include; ../../../../../../../sam0/drivers/system/clock/clock_samr34; ../../../../../../../common/utils; ../../../../../../../sam0/drivers/system/interrupt; ../../../../../../../sam0/drivers/system/power/power_sam_l; ../../..; ../../../utils; ../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samr34; ../../../../../../../sam0/boards/samr34_xplained_pro; ../../../../../../../sam0/utils/cmsis/samr34/source; ../../../../../../../sam0/drivers/extint/extint_sam_l_c; ..; ../../../../../../../common/boards; ../../../../../../../sam0/drivers/system/reset/reset_sam_l; ../../../../../../../sam0/drivers/system/pinmux; ../../../../../../../sam0/drivers/system; ../../../../../../../sam0/drivers/extint; ../../../../../../../sam0/utils/header_files; ../../../../../../../sam0/drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: boot_example_flash.bin
  ILINK.IlinkOutputFile: boot_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../sam0/utils/linker_scripts/samr34/iar/samr34j18b_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/wireless/addons/boot/bootloader/src
    ../../../bootloader/src/: eepromLoader.c abstractSerializer.c flashLoader.c uartSerializer.c app_info.c bootloader.c srecParser.c preparser.c hardwareInit.c
  group thirdparty/wireless/addons/boot/bootloader/inc
    ../../../bootloader/inc/: bootStructure.h eepromLoader.h boot_version.h appEntry.h app_info.h moveIntVector.h fcpu.h uartSerializer.h hardwareInit.h types.h preparser.h flashLoader.h srecParser.h abstractSerializer.h
  group thirdparty/wireless/addons/boot/example
    ../../: main.c
  group thirdparty/wireless/addons/boot/example/samr34_xpro
    ../: conf_sio2host.h conf_board.h conf_clocks.h conf_sio2ncp.h conf_extint.h
  group thirdparty/wireless/addons/boot/example/samr34_xpro/iar
    ./: asf.h
  group sam0/utils
    ../../../../../../../sam0/utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samr34/source
    ../../../../../../../sam0/utils/cmsis/samr34/source/: system_samr34.c system_samr34.h
  group sam0/utils/cmsis/samr34/source/iar
    ../../../../../../../sam0/utils/cmsis/samr34/source/iar/: startup_samr34.c
  group sam0/utils/cmsis/samr34/include
    ../../../../../../../sam0/utils/cmsis/samr34/include/: samr34j18b.h samr34j16b.h samr34.h samr34j17b.h
  group sam0/utils/cmsis/samr34/include/component
    ../../../../../../../sam0/utils/cmsis/samr34/include/component/: sercom.h nvmctrl.h dmac.h rtc.h oscctrl.h pac.h trng.h evsys.h tal.h eic.h osc32kctrl.h dsu.h supc.h port.h dac.h usb.h pm.h ac.h mclk.h tcc.h gclk.h rstc.h adc.h mtb.h ccl.h aes.h wdt.h tc.h
  group sam0/utils/cmsis/samr34/include/instance
    ../../../../../../../sam0/utils/cmsis/samr34/include/instance/: rstc.h tc3.h pm.h dmac.h sercom3.h wdt.h port.h trng.h sercom1.h evsys.h rtc.h dac.h osc32kctrl.h pac.h mclk.h mtb.h adc.h sercom4.h tcc2.h ac.h eic.h tcc1.h ccl.h dsu.h usb.h tal.h tc0.h gclk.h oscctrl.h nvmctrl.h sercom5.h supc.h tc2.h sercom2.h tc4.h sercom0.h tc1.h tcc0.h aes.h
  group sam0/utils/cmsis/samr34/include/pio
    ../../../../../../../sam0/utils/cmsis/samr34/include/pio/: samr34j18b.h samr34j16b.h samr34j17b.h
  group sam0/utils/preprocessor
    ../../../../../../../sam0/utils/preprocessor/: tpaste.h mrepeat.h mrecursion.h preprocessor.h stringz.h
  group sam0/utils/header_files
    ../../../../../../../sam0/utils/header_files/: io.h
  group sam0/drivers/port
    ../../../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/system
    ../../../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/interrupt
    ../../../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samr34
    ../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samr34/: system_interrupt_features.h
  group sam0/drivers/system/pinmux
    ../../../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/clock
    ../../../../../../../sam0/drivers/system/clock/: clock.h gclk.h
  group sam0/drivers/system/clock/clock_samr34
    ../../../../../../../sam0/drivers/system/clock/clock_samr34/: gclk.c clock.c clock_feature.h clock_config_check.h
  group sam0/drivers/system/power/power_sam_l
    ../../../../../../../sam0/drivers/system/power/power_sam_l/: power.h
  group sam0/drivers/system/reset/reset_sam_l
    ../../../../../../../sam0/drivers/system/reset/reset_sam_l/: reset.h
  group sam0/drivers/extint
    ../../../../../../../sam0/drivers/extint/: extint_callback.c extint.h extint_callback.h
  group sam0/drivers/extint/extint_sam_l_c
    ../../../../../../../sam0/drivers/extint/extint_sam_l_c/: extint.c
  group sam0/drivers/sercom
    ../../../../../../../sam0/drivers/sercom/: sercom.c sercom_interrupt.c sercom_pinout.h sercom.h sercom_interrupt.h
  group sam0/drivers/sercom/usart
    ../../../../../../../sam0/drivers/sercom/usart/: usart.c usart_interrupt.c usart_interrupt.h usart.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../../../../../../sam0/drivers/sercom/usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../../../../sam0/drivers/sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/sercom/usart/quick_start_lin
    ../../../../../../../sam0/drivers/sercom/usart/quick_start_lin/: qs_lin.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../../../../sam0/drivers/sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/nvm
    ../../../../../../../sam0/drivers/nvm/: nvm.c nvm.h
  group sam0/drivers/nvm/quick_start_basic
    ../../../../../../../sam0/drivers/nvm/quick_start_basic/: qs_nvm_basic.h
  group sam0/boards/samr34_xplained_pro
    ../../../../../../../sam0/boards/samr34_xplained_pro/: board_init.c samr34_xplained_pro.h
  group common/utils
    ../../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../common/boards/: board.h
