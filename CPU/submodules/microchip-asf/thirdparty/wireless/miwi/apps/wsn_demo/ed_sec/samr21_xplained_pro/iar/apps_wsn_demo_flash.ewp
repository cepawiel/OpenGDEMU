# IAR project apps_wsn_demo_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMR21G18A Atmel ATSAMR21G18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: SYSTICK_MODE; EXTINT_CALLBACK_MODE=true; RTC_COUNT_ASYNC=true; BOARD=SAMR21_XPLAINED_PRO; I2C_MASTER_CALLBACK_MODE=false; ARM_MATH_CM0PLUS=true; TC_ASYNC=true; OTAU_ENABLED; ENABLE_NETWORK_FREEZER; __SAMR21G18A__; PDS_ENABLE_WEAR_LEVELING; ENABLE_SLEEP_FEATURE; USART_CALLBACK_MODE=true; STB_ON_SAL; SPI_CALLBACK_MODE=false; PROTOCOL_MESH; SAL_TYPE=AT86RF2xx; ENDDEVICE; PHY_AT86RF233; MESH_SECURITY
  ICCARM.CCIncludePath2: ../../../../../../../../sam0/drivers/rtc; ../../../../../services/otau; ../../../../../../../../sam0/drivers/system/power; ../../../../../../../../sam0/drivers/system/clock/clock_samd21_r21_da_ha1; ../../../../../../../../sam0/drivers/sercom/i2c/i2c_sam0; ../../../../../../../../sam0/drivers/extint/extint_sam_d_r_h; ../../../../../include; ../../../../../../../../sam0/utils/preprocessor; ../../../../../../../../sam0/drivers/nvm; ../../../../../../../../sam0/utils/cmsis/samr21/source; ../../../../../../services/sal/inc; ../../../../../../../../common2/services/delay; ../../../../../../../../sam0/utils; ../../../../../source/miwi_mesh; ../../../../../../services/trx_access; ../../../../../services/otau/debug; ../../../../../source/mimac/phy; ../../..; ../../../../../../../../sam0/drivers/sercom; ../../../../../../../../sam0/drivers/port; ../../../../../../../../sam0/boards; ../../../../../../../../sam0/drivers/sercom/usart; ../../../../../../services/common_hw_timer/sam0; ../../../../../../../../common/services/serial; ../../../../../../../../sam0/drivers/sercom/i2c; ../../../../../services/otau/upgrade; ../../../../../source/stb/inc; ../../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samr21; ../../../../../../../../common/utils; ../../../../../../../../sam0/drivers/rtc/rtc_sam_d_r_h; ../../../../../../../../sam0/drivers/system/interrupt; ../../../../../../../../sam0/drivers/tc; ../../../../../../../../sam0/drivers/system/reset/reset_sam_d_r_h; ../../../../../services/pds/inc/nv; ../../../../../services/otau/notify; ../../../../../source/mimac; ..; ../../../../../../services/common_hw_timer; ../../../../../services/pds/inc/nv/External; ../../../../../../addons/sio2host/uart; ../../../../../../../../common2/services/delay/sam0; ../../../../../../services/edbg_eui; ../../../../../../../../sam0/drivers/sercom/spi; ../../../../../../../../sam0/boards/samr21_xplained_pro; ../../../../../../../../sam0/utils/cmsis/samr21/include; ../../../../../../../../sam0/drivers/system/power/power_sam_d_r_h; ../../../../../../../../sam0/drivers/tc/tc_sam_d_r_h; ../../../../../services/pds/inc; ../../../../../../../../common/boards; ../../../../../../../../sam0/drivers/system/pinmux; ../../../../../services/sleep_mgr; ../../../../../../../../sam0/drivers/system; ../../../../../services/pds/inc/wl; ../../../../../../../../sam0/drivers/extint; ../../../../../../../../sam0/drivers/system/reset; ../../../../../../../../sam0/utils/header_files; ../../../../../../services/nvm; ../../../../../../../../sam0/utils/stdio/stdio_serial; ../../../../../source/sys; ../../../../../../../../sam0/drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: apps_wsn_demo_flash.bin
  ILINK.IlinkOutputFile: apps_wsn_demo_flash.out
  ILINK.IlinkIcfFile: ../../../../../services/pds/src/wl/linkerscripts/samr21/iar/samr21g18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/wireless/miwi/source/miwi_mesh
    ../../../../../source/miwi_mesh/: miwi_mesh_app.c miwi_mesh_pds.c miwi_mesh_app.h
  group thirdparty/wireless/miwi/source/miwi_mesh/sam0/iar
    ../../../../../source/miwi_mesh/sam0/iar/: sam0_miwi_mesh_ed_sec.a
  group thirdparty/wireless/miwi/source/stb/src
    ../../../../../source/stb/src/: stb_armcrypto.c stb_help.c stb.c
  group thirdparty/wireless/miwi/source/stb/inc
    ../../../../../source/stb/inc/: stb.h stb_generic.h stb_internal.h stb_armcrypto.h
  group thirdparty/wireless/miwi/source/sys
    ../../../../../source/sys/: miqueue.c sysTimer.c mimem.c sysTimer.h mimem.h miqueue.h
  group thirdparty/wireless/miwi/source/mimac
    ../../../../../source/mimac/: mimac_at86rf.c mimac_at86rf.h
  group thirdparty/wireless/miwi/source/mimac/phy
    ../../../../../source/mimac/phy/: phy.h
  group thirdparty/wireless/miwi/source/mimac/phy/at86rf233
    ../../../../../source/mimac/phy/at86rf233/: phy.c
  group thirdparty/wireless/miwi/services/otau
    ../../../../../services/otau/: otau_parser.c circularBuffer.c otau.c otau_parser.h otau.h circularBuffer.h
  group thirdparty/wireless/miwi/services/otau/notify
    ../../../../../services/otau/notify/: server_notify.c client_notify.c otau_notify.h server_notify.h client_notify.h
  group thirdparty/wireless/miwi/services/otau/debug
    ../../../../../services/otau/debug/: client_debug.c server_debug.c client_debug.h server_debug.h otau_debug.h
  group thirdparty/wireless/miwi/services/otau/upgrade
    ../../../../../services/otau/upgrade/: client_upgrade.c server_upgrade.c otau_upgrade.h server_upgrade.h client_upgrade.h
  group thirdparty/wireless/miwi/services/pds/src/nv
    ../../../../../services/pds/src/nv/: D_Nv.c S_Nv-SamR21.c
  group thirdparty/wireless/miwi/services/pds/src/nv/External
    ../../../../../services/pds/src/nv/External/: D_XNv-SamR21.c S_Nv-External.c S_XNv.c
  group thirdparty/wireless/miwi/services/pds/src/wl
    ../../../../../services/pds/src/wl/: wlPdsTypesConverter.c wlPdsTaskManager.c wlPdsInit.c wlPdsDataServer.c
  group thirdparty/wireless/miwi/services/pds/src/nopds
    ../../../../../services/pds/src/nopds/: fakePds.c
  group thirdparty/wireless/miwi/services/pds/inc
    ../../../../../services/pds/inc/: pdsDataServer.h pdsMemIds.h
  group thirdparty/wireless/miwi/services/pds/inc/nv
    ../../../../../services/pds/inc/nv/: D_Nv.h D_Nv_Bindings.h S_Nv_Bindings.h S_Nv_Init.h S_Nv_Internal.h D_Nv_Init.h S_Nv.h
  group thirdparty/wireless/miwi/services/pds/inc/nv/External
    ../../../../../services/pds/inc/nv/External/: D_XNv_Init.h S_XNv_Bindings.h S_XNv_Init.h D_XNv.h S_XNv.h D_XNv_Bindings.h
  group thirdparty/wireless/miwi/services/pds/inc/wl
    ../../../../../services/pds/inc/wl/: wlPdsMemIds.h wlPdsBindings.h wlPdsTaskManager.h wlPdsTypes.h wlPdsTypesConverter.h
  group thirdparty/wireless/miwi/services/sleep_mgr
    ../../../../../services/sleep_mgr/: sleep_mgr.h
  group thirdparty/wireless/miwi/services/sleep_mgr/sam0
    ../../../../../services/sleep_mgr/sam0/: sleep_mgr.c
  group thirdparty/wireless/miwi/apps/wsn_demo
    ../../../: wsndemo.c commands.c main.c miwi_config.h config.h commands.h wsndemo.h miwi_config_mesh.h
  group thirdparty/wireless/miwi/apps/wsn_demo/ed_sec/samr21_xplained_pro
    ../: conf_trx_access.h conf_sio2host.h conf_rtc.h conf_board.h conf_hw_timer.h conf_sleepmgr.h conf_nvm.h conf_spi.h conf_clocks.h conf_extint.h
  group thirdparty/wireless/miwi/apps/wsn_demo/ed_sec/samr21_xplained_pro/iar
    ./: asf.h
  group thirdparty/wireless/miwi/include
    ../../../../../include/: miwi_api.h
  group thirdparty/wireless/services/common_hw_timer
    ../../../../../../services/common_hw_timer/: common_hw_timer.h
  group thirdparty/wireless/services/common_hw_timer/sam0
    ../../../../../../services/common_hw_timer/sam0/: hw_timer.c hw_timer.h
  group thirdparty/wireless/services/common_hw_timer/sam0/lib
    ../../../../../../services/common_hw_timer/sam0/lib/: sam0_lib_hw_timer.a
  group thirdparty/wireless/services/nvm
    ../../../../../../services/nvm/: common_nvm.h
  group thirdparty/wireless/services/nvm/sam0
    ../../../../../../services/nvm/sam0/: sam_nvm.c
  group thirdparty/wireless/services/sal/at86rf2xx/src
    ../../../../../../services/sal/at86rf2xx/src/: sal.c
  group thirdparty/wireless/services/sal/inc
    ../../../../../../services/sal/inc/: sal.h sal_types.h sal_generic.h
  group thirdparty/wireless/services/edbg_eui
    ../../../../../../services/edbg_eui/: edbg-eui.c edbg-eui.h
  group thirdparty/wireless/services/trx_access
    ../../../../../../services/trx_access/: trx_access.c trx_access.h
  group thirdparty/wireless/addons/sio2host/uart
    ../../../../../../addons/sio2host/uart/: sio2host.c sio2host.h
  group sam0/drivers/sercom
    ../../../../../../../../sam0/drivers/sercom/: sercom_interrupt.c sercom.c sercom_interrupt.h sercom.h sercom_pinout.h
  group sam0/drivers/sercom/usart
    ../../../../../../../../sam0/drivers/sercom/usart/: usart.c usart_interrupt.c usart_interrupt.h usart.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../../../../../sam0/drivers/sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../../../../../../../sam0/drivers/sercom/usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/sercom/usart/quick_start_lin
    ../../../../../../../../sam0/drivers/sercom/usart/quick_start_lin/: qs_lin.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../../../../../sam0/drivers/sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/sercom/spi
    ../../../../../../../../sam0/drivers/sercom/spi/: spi.c spi.h
  group sam0/drivers/sercom/spi/quick_start_master
    ../../../../../../../../sam0/drivers/sercom/spi/quick_start_master/: qs_spi_master_basic.h
  group sam0/drivers/sercom/spi/quick_start_dma
    ../../../../../../../../sam0/drivers/sercom/spi/quick_start_dma/: qs_spi_dma_use.h
  group sam0/drivers/sercom/spi/quick_start_slave
    ../../../../../../../../sam0/drivers/sercom/spi/quick_start_slave/: qs_spi_slave_basic.h
  group sam0/drivers/sercom/i2c
    ../../../../../../../../sam0/drivers/sercom/i2c/: i2c_master.h i2c_common.h
  group sam0/drivers/sercom/i2c/i2c_sam0
    ../../../../../../../../sam0/drivers/sercom/i2c/i2c_sam0/: i2c_master.c
  group sam0/drivers/sercom/i2c/quick_start_master
    ../../../../../../../../sam0/drivers/sercom/i2c/quick_start_master/: qs_i2c_master_basic_use.h
  group sam0/drivers/sercom/i2c/quick_start_master_dma
    ../../../../../../../../sam0/drivers/sercom/i2c/quick_start_master_dma/: qs_i2c_master_dma.h
  group sam0/drivers/system
    ../../../../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/interrupt
    ../../../../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samr21
    ../../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samr21/: system_interrupt_features.h
  group sam0/drivers/system/pinmux
    ../../../../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/clock
    ../../../../../../../../sam0/drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samd21_r21_da_ha1
    ../../../../../../../../sam0/drivers/system/clock/clock_samd21_r21_da_ha1/: gclk.c clock.c clock_feature.h clock_config_check.h
  group sam0/drivers/system/power/power_sam_d_r_h
    ../../../../../../../../sam0/drivers/system/power/power_sam_d_r_h/: power.h
  group sam0/drivers/system/reset/reset_sam_d_r_h
    ../../../../../../../../sam0/drivers/system/reset/reset_sam_d_r_h/: reset.h
  group sam0/drivers/nvm
    ../../../../../../../../sam0/drivers/nvm/: nvm.c nvm.h
  group sam0/drivers/nvm/quick_start_basic
    ../../../../../../../../sam0/drivers/nvm/quick_start_basic/: qs_nvm_basic.h
  group sam0/drivers/extint
    ../../../../../../../../sam0/drivers/extint/: extint_callback.c extint_callback.h extint.h
  group sam0/drivers/extint/extint_sam_d_r_h
    ../../../../../../../../sam0/drivers/extint/extint_sam_d_r_h/: extint.c
  group sam0/drivers/rtc
    ../../../../../../../../sam0/drivers/rtc/: rtc_count.h rtc_count_interrupt.h rtc_tamper.h
  group sam0/drivers/rtc/rtc_sam_d_r_h
    ../../../../../../../../sam0/drivers/rtc/rtc_sam_d_r_h/: rtc_count_interrupt.c rtc_count.c
  group sam0/drivers/tc
    ../../../../../../../../sam0/drivers/tc/: tc_interrupt.c tc.h tc_interrupt.h
  group sam0/drivers/tc/tc_sam_d_r_h
    ../../../../../../../../sam0/drivers/tc/tc_sam_d_r_h/: tc.c
  group sam0/drivers/port
    ../../../../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/utils
    ../../../../../../../../sam0/utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samr21/source
    ../../../../../../../../sam0/utils/cmsis/samr21/source/: system_samr21.c system_samr21.h
  group sam0/utils/cmsis/samr21/source/iar
    ../../../../../../../../sam0/utils/cmsis/samr21/source/iar/: startup_samr21.c
  group sam0/utils/cmsis/samr21/include
    ../../../../../../../../sam0/utils/cmsis/samr21/include/: samr21e16a.h samr21g16a.h samr21.h samr21g17a.h samr21e18a.h samr21e19a.h samr21e17a.h samr21g18a.h
  group sam0/utils/cmsis/samr21/include/component
    ../../../../../../../../sam0/utils/cmsis/samr21/include/component/: mtb.h tcc.h tc.h pm.h sercom.h evsys.h usb.h rfctrl.h dsu.h pac.h eic.h dmac.h nvmctrl.h ac.h sysctrl.h wdt.h gclk.h rtc.h adc.h port.h hmatrixb.h
  group sam0/utils/cmsis/samr21/include/instance
    ../../../../../../../../sam0/utils/cmsis/samr21/include/instance/: evsys.h tcc1.h rtc.h sercom4.h port.h sbmatrix.h pac1.h tcc0.h sysctrl.h mtb.h ac.h tcc2.h tc5.h pac2.h dmac.h rfctrl.h sercom1.h tc4.h dsu.h sercom3.h tc3.h pac0.h adc.h pm.h gclk.h usb.h sercom5.h sercom0.h eic.h wdt.h sercom2.h nvmctrl.h
  group sam0/utils/cmsis/samr21/include/pio
    ../../../../../../../../sam0/utils/cmsis/samr21/include/pio/: samr21g17a.h samr21g18a.h samr21e19a.h samr21e17a.h samr21g16a.h samr21e18a.h samr21e16a.h
  group sam0/utils/stdio
    ../../../../../../../../sam0/utils/stdio/: write.c read.c
  group sam0/utils/stdio/stdio_serial
    ../../../../../../../../sam0/utils/stdio/stdio_serial/: stdio_serial.h
  group sam0/utils/header_files
    ../../../../../../../../sam0/utils/header_files/: io.h
  group sam0/utils/preprocessor
    ../../../../../../../../sam0/utils/preprocessor/: preprocessor.h tpaste.h stringz.h mrepeat.h mrecursion.h
  group sam0/boards/samr21_xplained_pro
    ../../../../../../../../sam0/boards/samr21_xplained_pro/: board_init.c samr21_xplained_pro.h
  group common2/services/delay
    ../../../../../../../../common2/services/delay/: delay.h
  group common2/services/delay/sam0
    ../../../../../../../../common2/services/delay/sam0/: systick_counter.c systick_counter.h
  group common/utils
    ../../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/serial
    ../../../../../../../../common/services/serial/: serial.h
  group common/services/serial/sam0_usart
    ../../../../../../../../common/services/serial/sam0_usart/: usart_serial.h
  group common/boards
    ../../../../../../../../common/boards/: board.h
