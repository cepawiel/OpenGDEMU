# IAR project apps_simple_example_star_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMR21G18A Atmel ATSAMR21G18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: SYSTICK_MODE; PDS_ENABLE_WEAR_LEVELING; GFX_MONO_UG_2832HSWEG04=1; BOARD=SAMR21_XPLAINED_PRO; I2C_MASTER_CALLBACK_MODE=false; TC_ASYNC=true; EXTINT_CALLBACK_MODE=true; __SAMR21G18A__; ENABLE_NETWORK_FREEZER; ARM_MATH_CM0PLUS=true; USART_CALLBACK_MODE=true; SPI_CALLBACK_MODE=false; SAL_TYPE=AT86RF2xx; PROTOCOL_STAR; RTC_COUNT_ASYNC=true; PHY_AT86RF233
  ICCARM.CCIncludePath2: ../../../../../../../sam0/drivers/system/power; ../../../../../../../sam0/drivers/system/clock/clock_samd21_r21_da_ha1; ../../../../../../../sam0/drivers/sercom/i2c/i2c_sam0; ../../../../../../../sam0/drivers/extint/extint_sam_d_r_h; ../../../../include; ../../../../../../../sam0/utils/preprocessor; ../../../../../../../sam0/utils/cmsis/samr21/source; ../../../../../services/sal/inc; ../../../../../../../common2/services/delay; ../../../../../../../sam0/utils; ../../../../source/mimac; ../../../../../services/trx_access; ../../../../source/mimac/phy; ../../../../../../../sam0/drivers/sercom/spi; ../../../../../../../sam0/drivers/sercom; ../../../../../../../sam0/drivers/port; ../../../../../../../sam0/boards; ../../../../../../../sam0/drivers/sercom/usart; ../../../../../services/common_hw_timer/sam0; ../../../../../../../common/services/serial; ../../../../../../../common2/components/display/ssd1306; ../../../../../../../sam0/drivers/sercom/i2c; ../../../../services/pds/inc/nv; ../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samr21; ../../../../../../../common/utils; ../../../../../../../sam0/drivers/rtc/rtc_sam_d_r_h; ../../../../../../../sam0/drivers/system/interrupt; ../../../../../../../sam0/drivers/tc; ../../../../../../../sam0/drivers/system/reset/reset_sam_d_r_h; ../../../../../../../sam0/drivers/rtc; ..; ../..; ../../../../../../../sam0/drivers/nvm; ../../../../../services/common_hw_timer; ../../../../services/pds/inc/nv/External; ../../../../source/miwi_p2p_star; ../../../../../addons/sio2host/uart; ../../../../../../../common2/services/delay/sam0; ../../../../../services/edbg_eui; ../../../../../../../sam0/boards/samr21_xplained_pro; ../../../../../../../sam0/utils/cmsis/samr21/include; ../../../../../../../sam0/drivers/system/power/power_sam_d_r_h; ../../../../../../../common2/services/gfx_mono; ../../../../../../../sam0/drivers/tc/tc_sam_d_r_h; ../../../../services/pds/inc; ../../../../../../../common/boards; ../../../../services/lcd; ../../../../../../../sam0/drivers/system/pinmux; ../../../../services/sleep_mgr; ../../../../../../../sam0/drivers/system; ../../../../services/pds/inc/wl; ../../../../../../../sam0/drivers/extint; ../../../../../../../sam0/drivers/system/reset; ../../../../../../../sam0/utils/header_files; ../../../../../services/nvm; ../../../../../../../sam0/utils/stdio/stdio_serial; ../../../../source/sys; ../../../../../../../sam0/drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: apps_simple_example_star_flash.bin
  ILINK.IlinkOutputFile: apps_simple_example_star_flash.out
  ILINK.IlinkIcfFile: ../../../../services/pds/src/wl/linkerscripts/samr21/iar/samr21g18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/wireless/services/common_hw_timer
    ../../../../../services/common_hw_timer/: common_hw_timer.h
  group thirdparty/wireless/services/common_hw_timer/sam0
    ../../../../../services/common_hw_timer/sam0/: hw_timer.c hw_timer.h
  group thirdparty/wireless/services/common_hw_timer/sam0/lib
    ../../../../../services/common_hw_timer/sam0/lib/: sam0_lib_hw_timer.a
  group thirdparty/wireless/services/trx_access
    ../../../../../services/trx_access/: trx_access.c trx_access.h
  group thirdparty/wireless/services/edbg_eui
    ../../../../../services/edbg_eui/: edbg-eui.c edbg-eui.h
  group thirdparty/wireless/services/sal/at86rf2xx/src
    ../../../../../services/sal/at86rf2xx/src/: sal.c
  group thirdparty/wireless/services/sal/inc
    ../../../../../services/sal/inc/: sal_generic.h sal.h sal_types.h
  group thirdparty/wireless/services/nvm
    ../../../../../services/nvm/: common_nvm.h
  group thirdparty/wireless/services/nvm/sam0
    ../../../../../services/nvm/sam0/: sam_nvm.c
  group thirdparty/wireless/addons/sio2host/uart
    ../../../../../addons/sio2host/uart/: sio2host.c sio2host.h
  group thirdparty/wireless/miwi/services/lcd
    ../../../../services/lcd/: lcd.c lcd.h
  group thirdparty/wireless/miwi/services/pds/src/nv
    ../../../../services/pds/src/nv/: D_Nv.c S_Nv-SamR21.c
  group thirdparty/wireless/miwi/services/pds/src/nv/External
    ../../../../services/pds/src/nv/External/: D_XNv-SamR21.c S_XNv.c S_Nv-External.c
  group thirdparty/wireless/miwi/services/pds/src/wl
    ../../../../services/pds/src/wl/: wlPdsTypesConverter.c wlPdsDataServer.c wlPdsTaskManager.c wlPdsInit.c
  group thirdparty/wireless/miwi/services/pds/src/nopds
    ../../../../services/pds/src/nopds/: fakePds.c
  group thirdparty/wireless/miwi/services/pds/inc
    ../../../../services/pds/inc/: pdsDataServer.h pdsMemIds.h
  group thirdparty/wireless/miwi/services/pds/inc/nv
    ../../../../services/pds/inc/nv/: S_Nv_Init.h D_Nv_Bindings.h S_Nv.h D_Nv_Init.h D_Nv.h S_Nv_Bindings.h S_Nv_Internal.h
  group thirdparty/wireless/miwi/services/pds/inc/nv/External
    ../../../../services/pds/inc/nv/External/: S_XNv_Bindings.h D_XNv_Bindings.h D_XNv.h D_XNv_Init.h S_XNv_Init.h S_XNv.h
  group thirdparty/wireless/miwi/services/pds/inc/wl
    ../../../../services/pds/inc/wl/: wlPdsTaskManager.h wlPdsTypes.h wlPdsBindings.h wlPdsMemIds.h wlPdsTypesConverter.h
  group thirdparty/wireless/miwi/services/sleep_mgr
    ../../../../services/sleep_mgr/: sleep_mgr.h
  group thirdparty/wireless/miwi/services/sleep_mgr/sam0
    ../../../../services/sleep_mgr/sam0/: sleep_mgr.c
  group thirdparty/wireless/miwi/apps/simple_example_star
    ../../: demo_output.c star_demo.c task.c main.c miwi_config_p2p.h star_demo.h miwi_config.h demo_output.h task.h
  group thirdparty/wireless/miwi/apps/simple_example_star/samr21_xplained_pro
    ../: conf_trx_access.h conf_spinctrl.h conf_board.h conf_ssd1306.h conf_sio2host.h conf_rtc.h conf_nvm.h conf_spi.h conf_clocks.h conf_hw_timer.h conf_sysfont.h conf_extint.h
  group thirdparty/wireless/miwi/apps/simple_example_star/samr21_xplained_pro/iar
    ./: asf.h
  group thirdparty/wireless/miwi/source/mimac
    ../../../../source/mimac/: mimac_at86rf.c mimac_at86rf.h
  group thirdparty/wireless/miwi/source/mimac/phy
    ../../../../source/mimac/phy/: phy.h
  group thirdparty/wireless/miwi/source/mimac/phy/at86rf233
    ../../../../source/mimac/phy/at86rf233/: phy.c
  group thirdparty/wireless/miwi/source/miwi_p2p_star
    ../../../../source/miwi_p2p_star/: miwi_p2p_pds.c miwi_p2p_star.c miwi_p2p_star.h miwi_nvm.h
  group thirdparty/wireless/miwi/source/sys
    ../../../../source/sys/: mimem.c miqueue.c sysTimer.c miqueue.h mimem.h sysTimer.h
  group thirdparty/wireless/miwi/include
    ../../../../include/: miwi_api.h
  group sam0/drivers/sercom
    ../../../../../../../sam0/drivers/sercom/: sercom.c sercom_interrupt.c sercom_pinout.h sercom.h sercom_interrupt.h
  group sam0/drivers/sercom/spi
    ../../../../../../../sam0/drivers/sercom/spi/: spi.c spi.h
  group sam0/drivers/sercom/spi/quick_start_slave
    ../../../../../../../sam0/drivers/sercom/spi/quick_start_slave/: qs_spi_slave_basic.h
  group sam0/drivers/sercom/spi/quick_start_dma
    ../../../../../../../sam0/drivers/sercom/spi/quick_start_dma/: qs_spi_dma_use.h
  group sam0/drivers/sercom/spi/quick_start_master
    ../../../../../../../sam0/drivers/sercom/spi/quick_start_master/: qs_spi_master_basic.h
  group sam0/drivers/sercom/usart
    ../../../../../../../sam0/drivers/sercom/usart/: usart.c usart_interrupt.c usart_interrupt.h usart.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../../../../../../sam0/drivers/sercom/usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../../../../sam0/drivers/sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/sercom/usart/quick_start_lin
    ../../../../../../../sam0/drivers/sercom/usart/quick_start_lin/: qs_lin.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../../../../sam0/drivers/sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/sercom/i2c
    ../../../../../../../sam0/drivers/sercom/i2c/: i2c_common.h i2c_master.h
  group sam0/drivers/sercom/i2c/i2c_sam0
    ../../../../../../../sam0/drivers/sercom/i2c/i2c_sam0/: i2c_master.c
  group sam0/drivers/sercom/i2c/quick_start_master
    ../../../../../../../sam0/drivers/sercom/i2c/quick_start_master/: qs_i2c_master_basic_use.h
  group sam0/drivers/sercom/i2c/quick_start_master_dma
    ../../../../../../../sam0/drivers/sercom/i2c/quick_start_master_dma/: qs_i2c_master_dma.h
  group sam0/drivers/extint
    ../../../../../../../sam0/drivers/extint/: extint_callback.c extint.h extint_callback.h
  group sam0/drivers/extint/extint_sam_d_r_h
    ../../../../../../../sam0/drivers/extint/extint_sam_d_r_h/: extint.c
  group sam0/drivers/system
    ../../../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/interrupt
    ../../../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samr21
    ../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samr21/: system_interrupt_features.h
  group sam0/drivers/system/pinmux
    ../../../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/clock
    ../../../../../../../sam0/drivers/system/clock/: clock.h gclk.h
  group sam0/drivers/system/clock/clock_samd21_r21_da_ha1
    ../../../../../../../sam0/drivers/system/clock/clock_samd21_r21_da_ha1/: clock.c gclk.c clock_config_check.h clock_feature.h
  group sam0/drivers/system/power/power_sam_d_r_h
    ../../../../../../../sam0/drivers/system/power/power_sam_d_r_h/: power.h
  group sam0/drivers/system/reset/reset_sam_d_r_h
    ../../../../../../../sam0/drivers/system/reset/reset_sam_d_r_h/: reset.h
  group sam0/drivers/rtc
    ../../../../../../../sam0/drivers/rtc/: rtc_tamper.h rtc_count_interrupt.h rtc_count.h
  group sam0/drivers/rtc/rtc_sam_d_r_h
    ../../../../../../../sam0/drivers/rtc/rtc_sam_d_r_h/: rtc_count_interrupt.c rtc_count.c
  group sam0/drivers/tc
    ../../../../../../../sam0/drivers/tc/: tc_interrupt.c tc_interrupt.h tc.h
  group sam0/drivers/tc/tc_sam_d_r_h
    ../../../../../../../sam0/drivers/tc/tc_sam_d_r_h/: tc.c
  group sam0/drivers/port
    ../../../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/nvm
    ../../../../../../../sam0/drivers/nvm/: nvm.c nvm.h
  group sam0/drivers/nvm/quick_start_basic
    ../../../../../../../sam0/drivers/nvm/quick_start_basic/: qs_nvm_basic.h
  group sam0/utils
    ../../../../../../../sam0/utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samr21/source
    ../../../../../../../sam0/utils/cmsis/samr21/source/: system_samr21.c system_samr21.h
  group sam0/utils/cmsis/samr21/source/iar
    ../../../../../../../sam0/utils/cmsis/samr21/source/iar/: startup_samr21.c
  group sam0/utils/cmsis/samr21/include
    ../../../../../../../sam0/utils/cmsis/samr21/include/: samr21g18a.h samr21e17a.h samr21e18a.h samr21e16a.h samr21e19a.h samr21g17a.h samr21.h samr21g16a.h
  group sam0/utils/cmsis/samr21/include/instance
    ../../../../../../../sam0/utils/cmsis/samr21/include/instance/: rtc.h tc4.h dsu.h ac.h eic.h pac2.h pac0.h usb.h pm.h tc5.h port.h sercom2.h sbmatrix.h tcc1.h sercom4.h adc.h mtb.h gclk.h wdt.h sercom0.h sercom3.h tcc0.h sysctrl.h sercom5.h nvmctrl.h tcc2.h sercom1.h tc3.h rfctrl.h pac1.h evsys.h dmac.h
  group sam0/utils/cmsis/samr21/include/component
    ../../../../../../../sam0/utils/cmsis/samr21/include/component/: adc.h sysctrl.h usb.h gclk.h hmatrixb.h dsu.h sercom.h tcc.h dmac.h evsys.h rtc.h pm.h eic.h port.h nvmctrl.h wdt.h tc.h rfctrl.h pac.h ac.h mtb.h
  group sam0/utils/cmsis/samr21/include/pio
    ../../../../../../../sam0/utils/cmsis/samr21/include/pio/: samr21e19a.h samr21g17a.h samr21g18a.h samr21e16a.h samr21g16a.h samr21e17a.h samr21e18a.h
  group sam0/utils/stdio
    ../../../../../../../sam0/utils/stdio/: read.c write.c
  group sam0/utils/stdio/stdio_serial
    ../../../../../../../sam0/utils/stdio/stdio_serial/: stdio_serial.h
  group sam0/utils/preprocessor
    ../../../../../../../sam0/utils/preprocessor/: mrepeat.h mrecursion.h tpaste.h preprocessor.h stringz.h
  group sam0/utils/header_files
    ../../../../../../../sam0/utils/header_files/: io.h
  group sam0/boards/samr21_xplained_pro
    ../../../../../../../sam0/boards/samr21_xplained_pro/: board_init.c samr21_xplained_pro.h
  group common2/services/gfx_mono
    ../../../../../../../common2/services/gfx_mono/: gfx_mono_framebuffer.c gfx_mono_text.c gfx_mono_spinctrl.c gfx_mono_generic.c gfx_mono_ug_2832hsweg04.c sysfont.c gfx_mono_framebuffer.h gfx_mono_spinctrl.h gfx_mono_text.h gfx_mono.h sysfont.h gfx_mono_ug_2832hsweg04.h gfx_mono_generic.h
  group common2/services/delay
    ../../../../../../../common2/services/delay/: delay.h
  group common2/services/delay/sam0
    ../../../../../../../common2/services/delay/sam0/: systick_counter.c systick_counter.h
  group common2/components/display/ssd1306
    ../../../../../../../common2/components/display/ssd1306/: ssd1306.c ssd1306.h
  group common/utils
    ../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/serial
    ../../../../../../../common/services/serial/: serial.h
  group common/services/serial/sam0_usart
    ../../../../../../../common/services/serial/sam0_usart/: usart_serial.h
  group common/boards
    ../../../../../../../common/boards/: board.h
