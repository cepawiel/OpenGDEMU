# IAR project getting-started_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMR34J18B Atmel ATSAMR34J18B
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: SYSTICK_MODE; TC_ASYNC=true; EXTINT_CALLBACK_MODE=true; __SAMR34J18B__; ARM_MATH_CM0PLUS=true; USART_CALLBACK_MODE=true; BOARD=SAMR34_XPLAINED_PRO
  ICCARM.CCIncludePath2: ../../../../drivers/port; ../../../../drivers/system/reset; ../../../../utils/preprocessor; ../../../../../common2/services/delay; ..; ../../../../utils; ../../../../drivers/sercom; ../../../../drivers/system/power; ../../../../boards; ../../../../drivers/sercom/usart; ../../../../../common/services/serial; ../../../../utils/cmsis/samr34/include; ../../../../drivers/system; ../..; ../../../../drivers/tc/tc_sam_l_c; ../../../../../common/utils; ../../../../drivers/system/interrupt; ../../../../drivers/system/power/power_sam_l; ../../../../drivers/tc; ../../../../drivers/system/interrupt/system_interrupt_samr34; ../../../../boards/samr34_xplained_pro; ../../../../utils/cmsis/samr34/source; ../../../../drivers/extint/extint_sam_l_c; ../../../../../common2/services/delay/sam0; ../../../../../common/boards; ../../../../drivers/system/reset/reset_sam_l; ../../../../drivers/system/pinmux; ../../../../drivers/system/clock/clock_samr34; ../../../../drivers/extint; ../../../../utils/header_files; ../../../../utils/stdio/stdio_serial; ../../../../drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: getting-started_flash.bin
  ILINK.IlinkOutputFile: getting-started_flash.out
  ILINK.IlinkIcfFile: ../../../../utils/linker_scripts/samr34/iar/samr34j18b_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/utils
    ../../../../utils/: compiler.h status_codes.h
  group sam0/utils/stdio
    ../../../../utils/stdio/: read.c write.c
  group sam0/utils/stdio/stdio_serial
    ../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group sam0/utils/cmsis/samr34/source
    ../../../../utils/cmsis/samr34/source/: system_samr34.c system_samr34.h
  group sam0/utils/cmsis/samr34/source/iar
    ../../../../utils/cmsis/samr34/source/iar/: startup_samr34.c
  group sam0/utils/cmsis/samr34/include
    ../../../../utils/cmsis/samr34/include/: samr34j16b.h samr34j18b.h samr34.h samr34j17b.h
  group sam0/utils/cmsis/samr34/include/instance
    ../../../../utils/cmsis/samr34/include/instance/: nvmctrl.h tc3.h gclk.h osc32kctrl.h sercom1.h tc1.h sercom5.h ac.h mclk.h sercom3.h wdt.h evsys.h dac.h tc2.h dsu.h tc4.h usb.h eic.h tcc2.h rtc.h dmac.h tcc0.h sercom0.h trng.h ccl.h tc0.h sercom4.h sercom2.h tal.h aes.h tcc1.h mtb.h rstc.h port.h supc.h pm.h adc.h oscctrl.h pac.h
  group sam0/utils/cmsis/samr34/include/component
    ../../../../utils/cmsis/samr34/include/component/: dmac.h evsys.h rtc.h supc.h trng.h tc.h tal.h ac.h oscctrl.h gclk.h rstc.h aes.h dsu.h pm.h usb.h mtb.h ccl.h osc32kctrl.h eic.h sercom.h pac.h dac.h adc.h nvmctrl.h wdt.h port.h tcc.h mclk.h
  group sam0/utils/cmsis/samr34/include/pio
    ../../../../utils/cmsis/samr34/include/pio/: samr34j18b.h samr34j16b.h samr34j17b.h
  group sam0/utils/header_files
    ../../../../utils/header_files/: io.h
  group sam0/utils/preprocessor
    ../../../../utils/preprocessor/: mrepeat.h mrecursion.h tpaste.h stringz.h preprocessor.h
  group sam0/drivers/extint
    ../../../../drivers/extint/: extint_callback.c extint_callback.h extint.h
  group sam0/drivers/extint/extint_sam_l_c
    ../../../../drivers/extint/extint_sam_l_c/: extint.c
  group sam0/drivers/system
    ../../../../drivers/system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samr34
    ../../../../drivers/system/clock/clock_samr34/: gclk.c clock.c clock_config_check.h clock_feature.h
  group sam0/drivers/system/interrupt
    ../../../../drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samr34
    ../../../../drivers/system/interrupt/system_interrupt_samr34/: system_interrupt_features.h
  group sam0/drivers/system/pinmux
    ../../../../drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/reset/reset_sam_l
    ../../../../drivers/system/reset/reset_sam_l/: reset.h
  group sam0/drivers/system/power/power_sam_l
    ../../../../drivers/system/power/power_sam_l/: power.h
  group sam0/drivers/sercom
    ../../../../drivers/sercom/: sercom.c sercom_interrupt.c sercom.h sercom_pinout.h sercom_interrupt.h
  group sam0/drivers/sercom/usart
    ../../../../drivers/sercom/usart/: usart.c usart_interrupt.c usart_interrupt.h usart.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../drivers/sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../drivers/sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/sercom/usart/quick_start_lin
    ../../../../drivers/sercom/usart/quick_start_lin/: qs_lin.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../../../drivers/sercom/usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/tc
    ../../../../drivers/tc/: tc_interrupt.c tc_interrupt.h tc.h
  group sam0/drivers/tc/tc_sam_l_c
    ../../../../drivers/tc/tc_sam_l_c/: tc.c
  group sam0/drivers/port
    ../../../../drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../drivers/port/quick_start/: qs_port_basic.h
  group sam0/boards/samr34_xplained_pro
    ../../../../boards/samr34_xplained_pro/: board_init.c samr34_xplained_pro.h
  group sam0/applications/getting-started
    ../../: main.c
  group sam0/applications/getting-started/samr34j18b_samr34_xplained_pro
    ../: conf_uart_serial.h conf_board.h conf_clocks.h conf_extint.h
  group sam0/applications/getting-started/samr34j18b_samr34_xplained_pro/iar
    ./: asf.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../common/boards/: board.h
  group common/services/serial
    ../../../../../common/services/serial/: serial.h
  group common/services/serial/sam0_usart
    ../../../../../common/services/serial/sam0_usart/: usart_serial.h
  group common2/services/delay
    ../../../../../common2/services/delay/: delay.h
  group common2/services/delay/sam0
    ../../../../../common2/services/delay/sam0/: systick_counter.c systick_counter.h
